# Keil uVision project Lab2.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MK64FN1M0VLL12 NXP
  pack: Keil.Kinetis_SDK_DFP.2.2.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab2
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .\RTE\Device\MK64FN1M0VLL12\MK64FN1M0xxx12_flash.scf
  group Source Group 1
    ../Baja Stuff/en.stm32cubef4/STM32Cube_FW_F4_V1.15.0/Projects/STM32F429I-Discovery/Examples/GPIO/GPIO_EXTI/MDK-ARM/: startup_stm32f429xx.s
software components: CMSIS:CORE 5.0.0, Device:Startup 2.8
